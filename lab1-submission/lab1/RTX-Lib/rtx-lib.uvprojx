# Keil uVision project rtx-lib.uvprojx, settings and files
target RTX-Lib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtx-lib (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_0_
  c include: ..\include;..\include\bsp\LPC1768;.\src\librtx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group kernel
    ./src/kernel/: k_rtx_init.c k_mem.c k_mem_util.c
  group bsp
    ./src/bsp/lpc1768/: uart_polling.c
  group libu
    ./src/libu/: printf.c
