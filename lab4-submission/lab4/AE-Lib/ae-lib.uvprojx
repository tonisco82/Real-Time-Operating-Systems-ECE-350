# Keil uVision project ae-lib.uvprojx, settings and files
target AE Lib SIM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ae-lib-sim (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SIM_TARGET DEBUG_0
  c include: ..\include;..\include\bsp\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Documentation
    ./doc/: Abstract.txt TS200_G99_output.txt TS300_G99_output.txt
  group AE
    ./src/ae/: ae.c ae_util.c ae_tasks_util.c
    ./src/: main.c
  group AE-dummy-tasks
    ./src/ae/: ae_tasks.c
  group AE-public
    ./src/ae/: ae_tasks200_G99.c ae_tasks300_G99.c
  group AE-stu
    ./src/ae/: ae_tasks1_Gxx.c ae_tasks2_Gxx.c ae_tasks3_Gxx.c
target AE Lib RAM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: ae-lib-ram (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_0
  c include: ..\include;..\include\bsp\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
